# Keil uVision project MPU9250_TEST.uvprojx, settings and files
target MPU9250_TEST (ARM-ADS)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: MPU9250_TEST
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070xB
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f070xb.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c tasks.c list.c queue.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group Application/User
    ../Src/: gpio.c usart.c freertos.c main.c tim.c i2c.c stm32f0xx_it.c stm32f0xx_hal_msp.c mpu9250.c elecompass.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c.c stm32f0xx_hal.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_cortex.c
software components: CMSIS:CORE 4.3.0
